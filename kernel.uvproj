# Keil uVision project kernel.uvproj, settings and files
target kernel (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: kernel
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_code
    ./: startup_LPC17xx.s
  group system_code
    ./: system_LPC17xx.c
  group source_code
    ./: bridge.c bridge.h common_types.h HAL.c kernel_types.h main.c mem.c mem.h pq.c pq.h proc.c proc.h rtx.h timer.c timer.h uart.h uart_irq.c user.c user.h heap.c heap.h message_pq.c message_pq.h message.c message.h
